# Keil uVision project toggling_led_assending_and_decending_order.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: toggling_led_assending_and_decending_order +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 toggling_led_assending_and_decending_order.c
